# Keil uVision project EDF.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EDF
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\FreeRTOSv202112.00\FreeRTOS\Source\include;.\FreeRTOSv202112.00\FreeRTOS\Source\portable\GCC\ARM_CM4F;.\Config;.\Config\Inc;.\Mcal\Inc;.\Common;.\Hal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Appl
    ./Appl/: main.c
  group RTOS
    ./FreeRTOSv202112.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOSv202112.00/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./FreeRTOSv202112.00/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Mcal
    ./Mcal/: Dio.c Port.c
  group Config
    ./Config/: Dio_Lcfg.c Port_Lcfg.c FreeRTOSConfig.h
  group Hal
    ./Hal/: Led.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
